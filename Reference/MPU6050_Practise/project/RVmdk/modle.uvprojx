# Keil uVision project modle.uvprojx, settings and files
target FLASH (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: modle
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,USE_STM3210E_EVAL
  c include: ..\..\lib\fwlib\head;..\..\lib\fwlib\source;..\..\lib\cmsis;..\..\user\head;..\..\user\source;..\..\utilities\STM32_EVAL;..\..\utilities\STM32_EVAL\STM32100E_EVAL;..\..\utilities\STM32_EVAL\Common;..\..\utilities\STM32_EVAL\STM32100B_EVAL;..\..\utilities\STM32_EVAL\STM3210B_EVAL;..\..\utilities\STM32_EVAL\STM3210C_EVAL;..\..\utilities\STM32_EVAL\STM3210E_EVAL;..\..\utilities\STM32_EVAL\STM32L152_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../../lib/cmsis/startup/arm/: startup_stm32f10x_hd.s
  group cmsis
    ../../lib/cmsis/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group pwlib
    ../../lib/fwlib/source/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../../lib/fwlib/head/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group user
    ../../user/head/: stm32f10x_conf.h stm32f10x_it.h dmpKey.h dmpmap.h inv_mpu.h inv_mpu_dmp_motion_driver.h i2c.h mpu6050.h usart1.h delay.h
    ../../user/source/: main.c stm32f10x_it.c inv_mpu.c inv_mpu_dmp_motion_driver.c i2c.c mpu6050.c usart1.c delay.c
  group utilities
    ../../utilities/STM32_EVAL/: stm32_eval.c stm32_eval.h
target RAM (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: modle
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,USE_STM3210E_EVAL
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.0.0
